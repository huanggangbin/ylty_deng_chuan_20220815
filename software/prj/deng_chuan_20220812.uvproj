# Keil uVision project deng_chuan_20220812.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: deng_chuan_20220812 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
  group User
    ../User/: delay.c GPIO.c main.c spi.c timer.c UART.C
